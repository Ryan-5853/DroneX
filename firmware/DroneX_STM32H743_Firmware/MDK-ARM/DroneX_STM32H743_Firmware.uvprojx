# Keil uVision project DroneX_STM32H743_Firmware.uvprojx, settings and files
target DroneX_STM32H743_Firmware (ARM-ADS)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: DroneX_STM32H743_Firmware +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../User;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group User
    ../User/: User_main.c
  group User/Driver/IMU
    ../User/Driver/IMU/: IMU_interface.c ICM42688.c
  group User/Driver/Timing
    ../User/Driver/Timing/: Timing.c
  group User/Driver/Debug
    ../User/Driver/Debug/: Debug.c Debug_UART.c
  group User/Debug/Cmd
    ../User/Debug/CMD/: Cmd.c Cmd_handlers.c Cmd_cfg_table.c
  group User/Algorithm/Attitude_Est
    ../User/Algorithm/Attitude_Est/: Attitude_Est.c
  group User/Algorithm/Common/PID
    ../User/Algorithm/Common/PID/: PID.c
  group User/Algorithm/Att_Ctrl_PID
    ../User/Algorithm/Att_Ctrl_PID/: Att_Ctrl_PID.c
  group User/Application/Attitude
    ../User/Application/Attitude/: Attitude.c
  group User/Driver/ESC
    ../User/Driver/ESC/: ESC.c
  group User/Driver/RC
    ../User/Driver/RC/: RC.c
  group User/Driver/Vector_Gimbal
    ../User/Driver/Vector_Gimbal/: Vector_Gimbal.c
  group User/Driver/Flash
    ../User/Driver/Flash/: Flash_Param.c
software components: CMSIS:CORE 4.3.0
